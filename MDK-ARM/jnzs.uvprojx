# Keil uVision project jnzs.uvprojx, settings and files
target jnzs (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F429ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000-0x2002FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: jnzs
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F429xx
  c misc: --C99
  c include: ../Inc;../Middlewares/Third_Party/LwIP/src/include;../Middlewares/Third_Party/LwIP/system;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../Middlewares/Third_Party/LwIP/src/include/lwip;../Middlewares/Third_Party/LwIP/src/include/lwip/apps;../Middlewares/Third_Party/LwIP/src/include/lwip/priv;../Middlewares/Third_Party/LwIP/src/include/lwip/prot;../Middlewares/Third_Party/LwIP/src/include/netif;../Middlewares/Third_Party/LwIP/src/include/netif/ppp;../Middlewares/Third_Party/LwIP/src/include/netif/ppp/polarssl;../Middlewares/Third_Party/LwIP/src/include/posix;../Middlewares/Third_Party/LwIP/src/include/posix/sys;../Middlewares/Third_Party/LwIP/system/arch;../Drivers/CMSIS/Include
  asm include: ..\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  link misc: --diag_suppress=L6329
  group Middlewares/LwIP
    ../Middlewares/Third_Party/LwIP/src/core/ipv6/: ip6_frag.c nd6.c inet6.c icmp6.c mld6.c dhcp6.c ethip6.c ip6.c ip6_addr.c
    ../Middlewares/Third_Party/LwIP/src/netif/: lowpan6.c ethernet.c
    ../Middlewares/Third_Party/LwIP/src/netif/ppp/polarssl/: md5.c md4.c arc4.c des.c sha1.c
    ../Middlewares/Third_Party/LwIP/src/core/ipv4/: igmp.c autoip.c etharp.c dhcp.c icmp.c ip4_frag.c ip4.c ip4_addr.c
    ../Middlewares/Third_Party/LwIP/src/netif/ppp/: pppos.c pppol2tp.c vj.c pppapi.c ppp.c upap.c pppoe.c ecp.c utils.c auth.c lcp.c multilink.c chap-new.c eui64.c mppe.c demand.c eap.c ipv6cp.c fsm.c chap-md5.c magic.c ccp.c pppcrypt.c chap_ms.c ipcp.c
    ../Middlewares/Third_Party/LwIP/src/api/: err.c api_msg.c netdb.c netbuf.c tcpip.c netifapi.c api_lib.c sockets.c
    ../Middlewares/Third_Party/LwIP/src/core/: def.c tcp.c init.c sys.c pbuf.c tcp_in.c netif.c dns.c inet_chksum.c udp.c stats.c ip.c raw.c mem.c memp.c timeouts.c tcp_out.c
    ../Middlewares/Third_Party/LwIP/system/OS/: sys_arch.c
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group Application/MDK-ARM
    ./: startup_stm32f429xx.s
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
    ../Middlewares/Third_Party/FreeRTOS/Source/: timers.c event_groups.c queue.c tasks.c list.c croutine.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_sdram.c stm32f4xx_hal_rtc.c stm32f4xx_hal_dac_ex.c stm32f4xx_hal_crc.c stm32f4xx_hal_eth.c stm32f4xx_hal_sram.c stm32f4xx_hal_rcc.c stm32f4xx_hal_flash.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_tim.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_cortex.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_pwr.c stm32f4xx_ll_fmc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_dac.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_can.c stm32f4xx_hal.c stm32f4xx_hal_uart.c stm32f4xx_hal_adc.c stm32f4xx_hal_dma.c stm32f4xx_hal_iwdg.c
  group Application/User
    ../Src/: main.c ethernetif.c freertos.c stm32f4xx_it.c stm32f4xx_hal_timebase_TIM.c stm32f4xx_hal_msp.c lwip.c usart.c sdram.c task.c flash_if.c
software components: CMSIS:CORE 4.1.0
